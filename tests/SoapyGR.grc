options:
  parameters:
    generate_options: qt_gui
    id: SoapyGR
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '1000000'
  states: {}
- name: blocks_conjugate_cc_0
  id: blocks_conjugate_cc
  parameters: {}
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: samplesout.bin
    type: short
  states: {}
- name: blocks_file_sink_1
  id: blocks_file_sink
  parameters:
    file: samples.float
    type: complex
  states: {}
- name: blocks_interleaved_short_to_complex_0
  id: blocks_interleaved_short_to_complex
  parameters:
    scale_factor: '1.0'
    vector_input: 'False'
  states: {}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    type: short
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: soapy_custom_source_0
  id: soapy_custom_source
  parameters:
    agc0: 'True'
    antenna0: ''
    bandwidth0: '10000000'
    center_freq0: '1000000000'
    driver: sidekiq
    samp_rate: samp_rate
    type: sc16
  states: {}

connections:
- [blocks_conjugate_cc_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_interleaved_short_to_complex_0, '0', blocks_conjugate_cc_0, '0']
- [blocks_interleaved_short_to_complex_0, '0', blocks_file_sink_1, '0']
- [blocks_vector_to_stream_0, '0', blocks_file_sink_0, '0']
- [blocks_vector_to_stream_0, '0', blocks_interleaved_short_to_complex_0, '0']
- [soapy_custom_source_0, '0', blocks_vector_to_stream_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.3.0
